IMAGE_INSTALL:append = "${MACHINE_ESSENTIAL_EXTRA_RDEPENDS}"
