COMPATIBLE_MACHINE:imxgpu = "(mx8-nxp-bsp)"
