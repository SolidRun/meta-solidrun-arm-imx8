NNSHARK_SRC = "gitsm://source.codeaurora.org/external/imx/nnshark.git;protocol=https"
