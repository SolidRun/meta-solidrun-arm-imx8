IMAGE_INSTALL:append = " firmware-nxp-wifi-bcm43455-sr"
