# upstream renamed branch
SRC_URI:remove = " git://github.com/KhronosGroup/Vulkan-Loader.git;protocol=https;branch=master"
SRC_URI:append = " git://github.com/KhronosGroup/Vulkan-Loader.git;protocol=https;branch=main"
