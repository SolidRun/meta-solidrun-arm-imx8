# i.MX8 SolidRun SoMs support fTPM
COMPATIBLE_MACHINE:imx8dxl-sr-som  = "${MACHINE}"
COMPATIBLE_MACHINE:imx8mpsolidrun  = "imx8mpsolidrun"
