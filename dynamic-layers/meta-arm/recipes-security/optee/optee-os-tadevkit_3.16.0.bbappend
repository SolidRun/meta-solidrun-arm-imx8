# i.MX8DXL SolidRun SoM supports optee-os like mx8dxlevk
COMPATIBLE_MACHINE:imx8dxl-sr-som = "${MACHINE}"
OPTEEMACHINE:imx8dxl-sr-som = "imx-mx8dxlevk"

# i.MX8MP SolidRun SoM supports optee-os like imx8mpevk
COMPATIBLE_MACHINE:imx8mpsolidrun = "imx8mpsolidrun"
OPTEEMACHINE:imx8mpsolidrun = "imx-mx8mpevk"
