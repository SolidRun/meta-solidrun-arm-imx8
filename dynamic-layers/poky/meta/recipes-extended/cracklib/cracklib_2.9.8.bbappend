# upstream renamed branch
SRC_URI:remove = " git://github.com/cracklib/cracklib;protocol=https;branch=master"
SRC_URI:append = " git://github.com/cracklib/cracklib;protocol=https;branch=main"
