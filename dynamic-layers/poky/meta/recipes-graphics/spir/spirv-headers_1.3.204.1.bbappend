# upstream renamed branch
SRC_URI:remove = " git://github.com/KhronosGroup/SPIRV-Headers;protocol=https;branch=master"
SRC_URI:append = " git://github.com/KhronosGroup/SPIRV-Headers;protocol=https;branch=main"
