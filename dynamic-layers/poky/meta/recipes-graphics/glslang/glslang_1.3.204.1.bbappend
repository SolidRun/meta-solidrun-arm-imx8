# upstream renamed branch
SRC_URI:remove = " git://github.com/KhronosGroup/glslang.git;protocol=https;branch=master"
SRC_URI:append = " git://github.com/KhronosGroup/glslang.git;protocol=https;branch=main"
