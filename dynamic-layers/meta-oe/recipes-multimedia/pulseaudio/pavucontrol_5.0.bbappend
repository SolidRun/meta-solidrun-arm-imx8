# x11 support with libcanberra is currently broken
PACKAGECONFIG:remove = "x11"
