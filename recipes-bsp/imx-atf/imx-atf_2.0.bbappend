FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRCBRANCH = "imx_4.14.78_1.0.0_ga"

SRC_URI = "git://source.codeaurora.org/external/imx/imx-atf.git;protocol=https;branch=${SRCBRANCH}"

SRCREV = "d6451cc1e162eff89b03dd63e86d55b9baa8885b"


