COMPATIBLE_MACHINE = "(imx8mnsolidrun)"
