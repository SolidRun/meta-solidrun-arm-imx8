FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
        file://0001-Change-device-tree-to-solidrun-in-iMX8M-makefile.patch \
"
