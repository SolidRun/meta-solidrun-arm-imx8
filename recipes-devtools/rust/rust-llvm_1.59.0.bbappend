FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
        file://ff1681ddb303223973653f7f5f3f3435b48a1983.patch;striplevel=2 \
        file://5e9be93566f39ee6cecd579401e453eccfbe81e5.patch;striplevel=2 \
"
